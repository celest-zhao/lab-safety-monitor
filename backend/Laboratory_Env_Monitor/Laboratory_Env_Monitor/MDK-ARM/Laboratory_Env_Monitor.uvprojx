# Keil uVision project Laboratory_Env_Monitor.uvprojx, settings and files
target Laboratory_Env_Monitor (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431VCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: IoTV2_MainBoard +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c misc: --wchar32
  c include: ..\Inc;..\Drivers\STM32L4xx_HAL_Driver\Inc;..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\Drivers\CMSIS\Include;..\api;..\Hardware\LCD;..\Components\GUI;..\Components\log;..\Components\nb_at;..\Components\oc;..\task_user;..\Hardware\LED_Tran;..\Liteos\arch\arm\arm-m\include;..\Liteos\osdepends\liteos\cmsis;..\Liteos\osdepends\liteos\cmsis\1.0;..\Liteos\osdepends\liteos\cmsis\2.0;..\Liteos\kernel\base\include;..\Liteos\kernel\include;..\Liteos\kernel\extended\include;..\OS_CONFIG;..\Hardware\KEY;..\Hardware\ICON;..\Components\esp8285;..\Components\cJSON;..\Hardware\FUSION;..\Hardware\HANDLE;..\Hardware\AS312;..\Hardware\SHT30;..\Hardware\BH1750;..\Hardware\MQ_5;..\Hardware\Touch_Key;..\Hardware\LD3320;..\Middlewares\NanoEdgeAI;..\Components\offline_cache;..\Hardware\W25Q128
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Board/Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Board/Drivers/api
    ../Src/: adc.c can.c gpio.c i2c.c rtc.c spi.c stm32l4xx_hal_msp.c usart.c sysclk.c pwm.c net.c error.c
  group Board/Drivers/HAL
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Hardware
    ../Hardware/LCD/: lcd.c
    ../Hardware/KEY/: key.c
    ../Hardware/LED_Tran/: led.c
    ../Hardware/AS312/: as312.c
    ../Hardware/SHT30/: sht30.c
    ../Hardware/BH1750/: bh1750.c
    ../Hardware/MQ_5/: mq_5.c
    ../Hardware/FUSION/: fusion.c
    ../Hardware/Touch_Key/: touch_key.c
    ../Hardware/LD3320/: LD3320.c
    ../Hardware/W25Q128/: w25qxx.c
  group Components
    ../Components/GUI/: GUI.c
    ../Components/nb_at/: bc35g.c
    ../Components/oc/: ocprotocol.c
    ../Components/log/: log.c
    ../Components/esp8285/: esp8285.c HMACSHA.c sha256.c
    ../Components/cJSON/: cJSON.c cJSON_Utils.c
    ../Components/offline_cache/: offline_cache.c
  group Application/User
    ../task_user/: main.c stm32l4xx_it.c view_task.c control_task.c sensor_task.c ai_monitor.c
    ../Middlewares/NanoEdgeAI/: libneai.a
  group Huawei_LiteOS_Kernel
    ../Liteos/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../Liteos/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Liteos/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../Liteos/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../Liteos/kernel/base/mem/membox/: los_membox.c
    ../Liteos/kernel/base/misc/: los_misc.c
    ../Liteos/kernel/base/om/: los_err.c
    ../Liteos/kernel/extended/tickless/: los_tickless.c
    ../Liteos/kernel/: los_init.c
  group Huawei_LiteOS_Platform
    ../Liteos/arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
    ../Liteos/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
software components: CMSIS:CORE 4.3.0
